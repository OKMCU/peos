# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302VC ST STM32F302VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F302xC
  ICCARM.CCIncludePath2: ..\; ..\..\..\; ..\..\..\inc; ..\..\..\src; ..\libraries\CMSIS\Device\ST\STM32F3xx\Include; ..\libraries\STM32F3xx_LL_Driver\Inc; ..\hal
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: single-thread.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f302xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../application/: demo.c
  group CMSIS
    ./: startup_stm32f302xc.s
    ../hal/: system_stm32f3xx.c
  group components
    ../../../components/cli/: cli.c
    ../../../components/fifo/: fifo.c
    ../../../components/led/: led.c
    ../../../components/utilities/: rbuf.c
  group hal
    ../hal/: hal_drivers.c hal_pin.c hal_uart.c
  group kernel
    ../../../src/: st_clock.c st_msg.c st_sys.c st_task.c st_timer.c
  group kernel/heap
    ../../../src/umm_malloc/: umm_info.c umm_integrity.c umm_malloc.c umm_poison.c
  group kernel/portable
    ../: st_config.c st_portable.c
