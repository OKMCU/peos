# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K6 ST STM32L031K6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L031xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\; ..\..\..\inc; ..\..\..\src; ..\libraries\CMSIS\Device\ST\STM32L0xx\Include; ..\libraries\stm32l0xx_ll_driver; ..\hal
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: single-thread.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../application/: demo.c
  group CMSIS
    ./: startup_stm32l031xx.s
    ../hal/: system_stm32l0xx.c
  group components
    ../../../components/cli/: cli.c
    ../../../components/fifo/: fifo.c
    ../../../components/led/: led.c
    ../../../components/utilities/: rbuf.c stringx.c
  group hal
    ../hal/: board.c hal_pin.c hal_uart.c
  group kernel
    ../../../src/: os_clock.c os_msg.c os_sys.c os_task.c os_timer.c
    ../: os_config.c
  group kernel/heap
    ../../../src/umm_malloc/: umm_info.c umm_integrity.c umm_malloc.c umm_poison.c
